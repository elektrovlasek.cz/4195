Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-15T21:39:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 15 21:39:52 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F0967F5D-A1E6-4671-B2E8-A8712DE4B335}\ifc * Database version: 5507 * Database creation date: Mon Apr 15 21:39:51 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 15 21:39:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 15 21:39:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22744076_D_11104410_H7440BMX_GRGR, 11104410_D_H7440BMX_GRGR:22744076_D_11104410_H7440BMX_GRGR:205900
In: Level 1
Type - Classification: H7000 BM (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22744076_D_11104410_H7440BMX_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
